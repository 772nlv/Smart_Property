# Keil uVision project PRO_DAY2.uvprojx, settings and files
target Smart_ME (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PRO_DAY2 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,
  c include: ..\USER;..\FELIB\inc;..\CORE;..\SYSTEM\SYSTEM\delay;..\SYSTEM\SYSTEM\sys;..\HADEWARE\iic_at24c02_oled;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\FreeRTOS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group USER
    ./: system_stm32f4xx.c user.c user.h
  group SYSTEM
    ../SYSTEM/SYSTEM/sys/: sys.c
    ../SYSTEM/SYSTEM/delay/: delay.c
  group HADEWARE
    ./: led1.c func.c beep.c key.c interrupt.c uasrt.c timer.c pwm_fan.c DHT11.c adc.c ESP8266.c PWM_LED3.c TIM5.c PWM_BEEP.c key_4x4.c
    ../HADEWARE/: syn6288.c
  group IIC_dev_at24c02_oled
    ../HADEWARE/iic_at24c02_oled/: at24c02.c iic.c oled.c
  group spi_w25q64
    ../HADEWARE/spi_w25q64/: spi.c w25q64.c
  group FWLIB
    ../FELIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group DRIVER
    ./: lcd.c SPI.c GUI.c test.c
